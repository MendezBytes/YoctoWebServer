FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
do_configure:prepend(){
echo "Please work?"
}
